# Keil uVision project Labo1.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x20010000,0x0003C000) IROM(0x08000000,0x00100000) IROM2(0x00200000,0x00100000) XRAM(0x2004C000,0x00004000) XRAM2(0x40024000,0x00001000) XRAM3(0x00000000,0x00004000) CPUTYPE("Cortex-M7") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: labo1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT6: RAM 0x2004c000 size 0x4000
  memory RVCT7: RAM 0x40024000 size 0x1000
  memory RVCT8: RAM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x3c000
  group Source Group 1
    ./: main.s main_with_bug.s
software components: CMSIS:CORE 6.1.1, Hesso pack:Assembler main call 1.0.0, Hesso pack:Extension Board:Buttons 1.0.0, Hesso pack:Extension Board:LEDs 1.0.0, Device:STM32Cube Framework:Classic 1.2.7, Device:STM32Cube HAL:Common 1.2.7, Device:STM32Cube HAL:Cortex 1.2.7, Device:STM32Cube HAL:GPIO 1.2.7, Device:STM32Cube HAL:PWR 1.2.7, Device:STM32Cube HAL:RCC 1.2.7, Device:Startup 1.2.4
